SUMMARY = "Python implementation of the multihash specification"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ee12a4da6b4a367c291e0025c7116846"

SRC_URI[md5sum] = "f4fca3382b8d817c48e96a273accd224"
SRC_URI[sha256sum] = "49c75a1ae9ecc6d22d259064d4597b3685da3f0258f4ded632e03a3a79af215b"

PYPI_PACKAGE = "pymultihash"

inherit pypi setuptools3

